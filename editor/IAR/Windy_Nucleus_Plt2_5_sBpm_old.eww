<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Windy_Nucleus_Plt_2_5_sBpm_old.ewp</path>
  </project>
  <batchBuild/>
</workspace>


