# IAR project Windy_Nucleus_Plt_2_5_sBpm_old.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV30F128xxx10 Freescale MKV30F128xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: ext.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group (top)
    ../../exe/: Windy_Mcu_Nucleus_Plt_2_5_sBpm.out
